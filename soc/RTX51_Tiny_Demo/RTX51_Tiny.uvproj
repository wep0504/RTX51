# Keil uVision project RTX51_Tiny.uvproj, settings and files
target RTX51 Tiny (MCS-51)
  device: SC95F8617 SC95Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0xFFF) CLOCK(32000000)
  output: RTX51_Tiny +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\SC95F7617B_7616B_7615B_7613B_Demo_Code\H
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51 Conf_tny.A51 rtx_app.c uart.c
